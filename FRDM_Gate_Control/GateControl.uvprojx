# Keil uVision project GateControl.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.0
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: GateControl
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group Source Group 1
    ./Src/: esp32.cpp ir_BoseWave.cpp ir_Denon.cpp ir_Dish.cpp ir_JVC.cpp ir_Lego_PF.cpp ir_Lego_PF_BitStreamEncoder.h ir_LG.cpp ir_MagiQuest.cpp ir_NEC.cpp ir_Panasonic.cpp ir_RC5_RC6.cpp ir_Samsung.cpp ir_Sanyo.cpp ir_Sharp.cpp ir_Sharp_alt.cpp ir_Sony.cpp ir_Template.cpp ir_Whynter.cpp irPronto.cpp irReceive.cpp IRremote.cpp IRremote.h irSend.cpp nRF5.cpp sam.cpp
